# IAR project user.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pe513,Pa050
  ICCARM.CCIncludePath2: ..\..\drivers\inc; ..\..\freertos\include; ..\..\common\user; ..\..\ci_denoise; $PROJ_DIR$..\..\..\bsp_test\inc; ..\..\..\bsp_test\src; ..\..\freertos\portable\IAR\ARM_CM4F; ..\..\fatfs
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.AUserIncludes: ..\..\common\user
  OBJCOPY.OOCOutputFile: user.bin
  ILINK.IlinkOutputFile: user.out
  ILINK.IlinkIcfFile: ci100x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group bsp_test/src
    ../../bsp_test/src/: adpcm.c cs42l52.c iic_cx.c smt_adc.c smt_at24c08b.c smt_can.c smt_cs42l52.c smt_gpio.c smt_iis.c smt_iwdg.c smt_mpu.c smt_pwm.c smt_scu.c smt_sd.c smt_sdram.c smt_spiflash.c smt_timer.c smt_twdg.c smt_uart.c smt_xpwm.c Utils.c
  group bsp_test/src/cxdish
    ../../bsp_test/src/cxdish/: command.h common.h cxdish.c cxdish.h CxFlash.c CxFlash.h host_depend.c
  group ci_denoise
    ../../ci_denoise/: ci_denoise.c ci_denoise.h denoise_api.h denoise_debug_0.1.0.a
  group driver/source
    ../../drivers/src/: ci100x_adc.c ci100x_can.c ci100x_dma.c ci100x_gpio.c ci100x_i2c.c ci100x_ir.c ci100x_mpu.c ci100x_pwm.c ci100x_scu.c ci100x_sd.c ci100x_sdram.c ci100x_spi.c ci100x_spiflash.c ci100x_suart.c ci100x_timer.c ci100x_TimerWdt.c ci100x_uart.c ci100x_wdt.c ci100x_xpwm.c misc.c
  group fatfs
    ../../fatfs/: ccsbcs.c diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group freeRTOS
    ../../freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../freertos/portable/MemMang/: heap_4.c
    ../../freertos/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group lib
    ../../lib/: asr_driver_v2.3_20181109.a cikd_asr0.6.5.1.a
  group Readme
    ../../: version.txt
  group startup
    ../../common/user/: ci100x_malloc.c ci100x_startup.c system_ci100x.c
  group user
    ../../common/user/: asr_api.h ci100x_asrcmd.c ci100x_asrcmd.h ci100x_global.c ci100x_global.h ci100x_it.c ci100x_it.h com2_task.c Fw_updata.c gpio_config.h includes.h main.c nvdata_save.c platform_config.h sh86313.c task_asr.c Task_key.c test_stamp_board.c user_config.h user_main.c user_main.h
